PACKAGECONFIG:append = " panfrost"
