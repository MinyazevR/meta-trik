require trik-image-core.bb

IMAGE_INSTALL += "\
		packagegroup-core-tools-debug \
"
