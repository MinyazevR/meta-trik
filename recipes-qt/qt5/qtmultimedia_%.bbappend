DEPENDS += "qtbase"
PACKAGECONFIG:remove = "gstreamer010"
PACKAGECONFIG:remove = "pulseaudio"
