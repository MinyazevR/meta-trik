PACKAGECONFIG:remove = "lame mpg123"
# qmlglsink / GstGLVideoItem for Qt5 QML display integration.
PACKAGECONFIG:append = " qt5"